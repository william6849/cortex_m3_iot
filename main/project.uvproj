# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\lib\inc;..\cmsis;..\main;..\startup
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../startup/: startup_stm32f10x_md.s
  group cmsis
    ../cmsis/: core_cm3.c system_stm32f10x.c
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group main
    ./: main.c stm32f10x_it.c led.c usart.c led.h usart.h esp_connect.c esp_connect.h var.c var.h adc.c adc.h
